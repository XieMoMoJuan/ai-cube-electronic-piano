# Keil uVision project aicubepro1_bk1.uvproj, settings and files
target aicubepro1 (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: aicubepro1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Sources\inc
  group AiCube
    ./Sources/: main.c
    ./Sources/lib/: stc_usb_cdc_8h_xdata_bl51.lib
